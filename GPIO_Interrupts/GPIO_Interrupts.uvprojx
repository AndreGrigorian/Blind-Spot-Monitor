# Keil uVision project GPIO_Interrupts.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_Interrupts
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group inc
    ./: GPIO.h SysTick_Delay.h EduBase_Button_Interrupt.h PMOD_BTN_Interrupt.h UART0.h
  group src
    ./: GPIO.c SysTick_Delay.c EduBase_Board_Interrupt.c PMOD_BTN_Interrupt.c UART0.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
